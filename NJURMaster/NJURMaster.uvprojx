# Keil uVision project NJURMaster.uvprojx, settings and files
target RoboMaster (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NJURMaster +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427XXX
  c include: .\Libraries\Protocol;.\Libraries\RmLib;.\Libraries\STLibraries;.\drivers\IMU;.\applications;.\users;..\NJURMaster;.\drivers\LED;.\drivers\DELAY;.\drivers\USART;.\drivers\SYS;.\drivers\DRIVER;.\drivers\MPU6500;.\Libraries\FatFs;.\drivers\LASER;.\drivers\TIMER;.\task;.\drivers\CAN;.\drivers\FLASH;.\drivers\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group applications
    ./applications/: PID.c mymath.c filter.c duty.c
  group drivers
    ./drivers/DRIVER/: driver.c
    ./drivers/LED/: led.c
    ./drivers/DELAY/: delay.c
    ./drivers/USART/: rc.c usart2.c usart3.c
    ./drivers/LASER/: laser.c
    ./drivers/TIMER/: timer.c
    ./drivers/CAN/: can.c
    ./drivers/FLASH/: bsp_flash.c
    ./drivers/PWM/: pwm.c
  group Libraries
    ./Libraries/STLibraries/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c system_stm32f4xx.c misc.c
  group users
    ./users/: main.c stm32f4xx_it.c startup_stm32f427_437xx.s
  group imu
    ./drivers/MPU6500/: mpu6500.c mpu6500_spi.c
  group RmLib
    ./Libraries/RmLib/: RMLib.lib common.h fifo.h LostCounter.h pid_regulator.h ramp.h
  group Protocol
    ./Libraries/Protocol/: Protocol.lib MF_CRC16.h protocal.h
  group task
    ./applications/: datatransfer.c
    ./task/: ControlTask.c CanBusTask.c RemoteTask.c
